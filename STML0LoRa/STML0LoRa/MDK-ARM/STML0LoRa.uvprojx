# Keil uVision project STML0LoRa.uvprojx, settings and files
target STML0LoRa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STML0LoRa +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L072xx, REGION_AS923,USE_B_L072Z_LRWAN1
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/CMWX1ZZABZ-0xx;../Drivers/BSP/Components/Common;../Drivers/BSP/Components/hts221;../Drivers/BSP/Components/lps22hb;../Drivers/BSP/Components/lps25hb;../Drivers/BSP/Components/sx1276;../Drivers/BSP/X_NUCLEO_IKS01A2;../Drivers/BSP/B-L072Z-LRWAN1;../Middlewares/Third_Party/LoRaWAN/Crypto;../Middlewares/Third_Party/LoRaWAN/Mac;../Middlewares/Third_Party/LoRaWAN/Phy;../Middlewares/Third_Party/LoRaWAN/Utilities;../Middlewares/Third_Party/LoRaWAN/Patterns/Basic;../Middlewares/Third_Party/LoRaWAN/Mac/region;../LoRaWAN/App/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l072xx.s
  group Application/User
    ../Src/: main.c gpio.c sys.c usart.c mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c
    ../LoRaWAN/App/src/: bsp.c debug.c hw_gpio.c hw_rtc.c hw_spi.c vcom.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_spi.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_rtc.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../Drivers/BSP/Components/sx1276/: sx1276.c
  group Drivers/BSP/X_NUCLEO_IKS01A2
    ../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/BSP/CMWX1ZZABZ-0xx
    ../Drivers/BSP/CMWX1ZZABZ-0xx/: mlm32l07x01.c
  group B-L072Z-LRWAN1
    ../Drivers/BSP/B-L072Z-LRWAN1/: b-l072z-lrwan1.c
  group Middlewares/LoRaWAN/Patterns/Basic
    ../Middlewares/Third_Party/LoRaWAN/Patterns/Basic/: lora.c lora-test.c
  group Middlewares/LoRaWAN/Mac
    ../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
  group Middlewares/LoRaWAN/Mac/Regions
    ../Middlewares/Third_Party/LoRaWAN/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
  group Middlewares/LoRaWAN/Utilities
    ../Middlewares/Third_Party/LoRaWAN/Utilities/: low_power_manager.c queue.c systime.c timeServer.c trace.c utilities.c
  group Middlewares/LoRaWAN/Crypto
    ../Middlewares/Third_Party/LoRaWAN/Crypto/: aes.c cmac.c soft-se.c
software components: CMSIS:CORE 4.3.0
